options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: datacast_tx_demo
    output_language: python
    realtime_scheduling: '1'
    title: ISDB-Tb Datacast TX Demo
  states: {}

blocks:
- name: isdbt_datacast_tx_0
  id: isdbt_datacast_tx
  parameters:
    comment: |-
      Reemplaza blocks_file_source_0: encapsula trafico IP/UDP
      capturado desde la interfaz TUN en secciones MPE sobre PID
      privado, en vez de leer un layer_a.ts estatico.
    interface: '"tun0"'
    modulation: '"QPSK"'
    fec: '"2/3"'
    private_pid: '0x0100'
    dst_mac: '"FF:FF:FF:FF:FF:FF"'
    heartbeat_interval: '0.1'
    queue_limit: '5000'
    carousel_repeats: '3'
  states: {}
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: bb_gain
  id: variable_qtgui_entry
  parameters:
    label: BB gain
    type: real
    value: '0.0022097087'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 593.143e6
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: length_a
  id: variable
  parameters:
    value: '4'
  states: {}
- name: length_b
  id: variable
  parameters:
    value: '2'
  states: {}
- name: length_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: samp_rate_usrp
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: segments_a
  id: variable
  parameters:
    value: '1'
  states: {}
- name: segments_b
  id: variable
  parameters:
    value: '12'
  states: {}
- name: segments_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '80'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/persistent/layer_b.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: bb_gain
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: See sec. 3.9.2 of the standard.
    num_items: '2'
    type: complex
    vlen: data_carriers
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: 1512*4
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 1512*4
    type: byte
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: int(total_carriers*guard)
    input_size: total_carriers
    tagname: ''
  states: {}
- name: dtv_dvbt_inner_coder_0_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C2_3
    constellation: 16qam
    hierarchy: alpha4
    ninput: '1'
    noutput: 1512*4
  states: {}
- name: dtv_dvbt_inner_coder_0_0_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C3_4
    constellation: 64qam
    hierarchy: alpha4
    ninput: '1'
    noutput: 1512*4
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: total_carriers
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(total_carriers)
  states: {}
- name: isdbt_byte_interleaver_0
  id: isdbt_byte_interleaver
  parameters:
    constellation_size: '16'
    mode: '3'
    nsegments: segments_a
    rate: '1'
  states: {}
- name: isdbt_byte_interleaver_0_0
  id: isdbt_byte_interleaver
  parameters:
    constellation_size: '64'
    mode: '3'
    nsegments: segments_b
    rate: '2'
  states: {}
- name: isdbt_carrier_modulation_0
  id: isdbt_carrier_modulation
  parameters:
    constellation_size: '16'
    mode: '3'
    segments: segments_a
  states: {}
- name: isdbt_carrier_modulation_0_0
  id: isdbt_carrier_modulation
  parameters:
    constellation_size: '64'
    mode: '3'
    segments: segments_b
  states: {}
- name: isdbt_energy_dispersal_0
  id: isdbt_energy_dispersal
  parameters:
    constellation_size: '16'
    mode: '3'
    nsegments: segments_a
    rate: '1'
  states: {}
- name: isdbt_energy_dispersal_0_0
  id: isdbt_energy_dispersal
  parameters:
    constellation_size: '64'
    mode: '3'
    nsegments: segments_b
    rate: '2'
  states: {}
- name: isdbt_frequency_interleaver_0
  id: isdbt_frequency_interleaver
  parameters:
    mode: '3'
    oneseg: 'True'
  states: {}
- name: isdbt_hierarchical_combinator_0
  id: isdbt_hierarchical_combinator
  parameters:
    mode: '3'
    segments_A: segments_a
    segments_B: segments_b
    segments_C: '0'
  states: {}
- name: isdbt_pilot_signals_0
  id: isdbt_pilot_signals
  parameters:
    mode: '3'
  states: {}
- name: isdbt_time_interleaver_0
  id: isdbt_time_interleaver
  parameters:
    length_A: length_a
    length_B: length_b
    length_C: length_c
    mode: '3'
    segments_A: segments_a
    segments_B: segments_b
    segments_C: segments_c
  states: {}
- name: isdbt_tmcc_encoder_0
  id: isdbt_tmcc_encoder
  parameters:
    conv_code_A: '1'
    conv_code_B: '2'
    conv_code_C: '0'
    int_length_A: length_a
    int_length_B: length_b
    int_length_C: '0'
    mod_scheme_A: '4'
    mod_scheme_B: '64'
    mod_scheme_C: '4'
    mode: '3'
    nsegs_A: segments_a
    nsegs_B: segments_b
    nsegs_C: '0'
    one_seg_present: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '64'
    interp: '63'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate_usrp
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [isdbt_datacast_tx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_1_0, '0']
- [blocks_skiphead_0, '0', isdbt_pilot_signals_0, '0']
- [blocks_stream_to_vector_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_stream_to_vector_0_0, '0', dtv_dvbt_reed_solomon_enc_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', isdbt_carrier_modulation_0, '0']
- [blocks_vector_to_stream_0_1_0, '0', isdbt_carrier_modulation_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_xx_0, '0']
- [dtv_dvbt_inner_coder_0_0, '0', blocks_vector_to_stream_0_1, '0']
- [dtv_dvbt_inner_coder_0_0_0, '0', blocks_vector_to_stream_0_1_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', isdbt_energy_dispersal_0, '0']
- [dtv_dvbt_reed_solomon_enc_0_0, '0', isdbt_energy_dispersal_0_0, '0']
- [fft_vxx_1, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [isdbt_byte_interleaver_0, '0', dtv_dvbt_inner_coder_0_0, '0']
- [isdbt_byte_interleaver_0_0, '0', dtv_dvbt_inner_coder_0_0_0, '0']
- [isdbt_carrier_modulation_0, '0', isdbt_hierarchical_combinator_0, '0']
- [isdbt_carrier_modulation_0_0, '0', isdbt_hierarchical_combinator_0, '1']
- [isdbt_energy_dispersal_0, '0', isdbt_byte_interleaver_0, '0']
- [isdbt_energy_dispersal_0_0, '0', isdbt_byte_interleaver_0_0, '0']
- [isdbt_frequency_interleaver_0, '0', blocks_skiphead_0, '0']
- [isdbt_hierarchical_combinator_0, '0', isdbt_time_interleaver_0, '0']
- [isdbt_pilot_signals_0, '0', isdbt_tmcc_encoder_0, '0']
- [isdbt_time_interleaver_0, '0', isdbt_frequency_interleaver_0, '0']
- [isdbt_tmcc_encoder_0, '0', fft_vxx_1, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
