options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rx_demo
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: Center freq.
    type: int
    value: '593143000'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/persistent/result_layer_b.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/persistent/result_layer_b.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/persistent/569MHz_recording.dat
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: '1152'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: data_carriers
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Null Trasher',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

      # Filtro rápido para el receptor
      def work(self, input_items, output_items):
          in_data = input_items[0]
          # Solo dejamos pasar si NO es un paquete nulo (PID 1FFF)
          # El PID está en los bytes 1 y 2 (13 bits)
          if not (in_data[1] & 0x1F == 0x1F and in_data[2] == 0xFF):
              # Aquí enviarías el paquete al sink
              pass
  states: {}
- name: isdbt_bit_deinterleaver_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '64'
    mode: '3'
    segments: '10'
  states: {}
- name: isdbt_bit_deinterleaver_0_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '16'
    mode: '3'
    segments: '3'
  states: {state: disabled}
- name: isdbt_byte_deinterleaver_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_byte_deinterleaver_0_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {state: disabled}
- name: isdbt_energy_descrambler_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_energy_descrambler_0_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {state: disabled}
- name: isdbt_frequency_deinterleaver_0
  id: isdbt_frequency_deinterleaver
  parameters:
    mode: '3'
    oneseg: 'True'
  states: {}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.0625'
    interpolate: 'False'
    mode: '3'
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {state: disabled}
- name: isdbt_symbol_demapper_0
  id: isdbt_symbol_demapper
  parameters:
    constellation_size_A: '16'
    constellation_size_B: '64'
    constellation_size_C: '64'
    mode: '3'
    segments_A: '3'
    segments_B: '10'
    segments_C: '0'
  states: {}
- name: isdbt_time_deinterleaver_0
  id: isdbt_time_deinterleaver
  parameters:
    length_A: '1'
    length_B: '6'
    length_C: '0'
    mode: '3'
    segments_A: '3'
    segments_B: '10'
    segments_C: '0'
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    mode: '3'
    print_params: 'False'
  states: {}
- name: isdbt_viterbi_decoder_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '64'
    rate: '2'
  states: {}
- name: isdbt_viterbi_decoder_0_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '16'
    rate: '0'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 'samp_rate / 2 * 0.9 '
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '2001'
    send_eof: 'False'
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: active_carriers
    type: complex
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-35'
    name: '"BER post-Viterbi (log10)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-35'
    name: '"BER post-Viterbi (log10)"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-10'
    name: '"BER pre-Viterbi (log10)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-10'
    name: '"BER pre-Viterbi (log10)"'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '30'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [blocks_file_source_1_0, '0', blocks_throttle_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_number_sink_0_1_0, '0']
- [blocks_nlog10_ff_0_1, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_1, '0']
- [blocks_vector_to_stream_0, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_null_sink_1_0, '0']
- [blocks_vector_to_stream_0_0, '0', network_udp_sink_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', network_udp_sink_0, '0']
- [isdbt_bit_deinterleaver_0, '0', isdbt_viterbi_decoder_0, '0']
- [isdbt_bit_deinterleaver_0_0, '0', isdbt_viterbi_decoder_0_0, '0']
- [isdbt_byte_deinterleaver_0, '0', isdbt_energy_descrambler_0, '0']
- [isdbt_byte_deinterleaver_0_0, '0', isdbt_energy_descrambler_0_0, '0']
- [isdbt_energy_descrambler_0, '0', isdbt_reed_solomon_dec_isdbt_0, '0']
- [isdbt_energy_descrambler_0_0, '0', isdbt_reed_solomon_dec_isdbt_0_0, '0']
- [isdbt_frequency_deinterleaver_0, '0', isdbt_time_deinterleaver_0, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '0', blocks_vector_to_stream_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '1', blocks_nlog10_ff_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0, '1', blocks_nlog10_ff_0_1, '0']
- [isdbt_symbol_demapper_0, '0', blocks_null_sink_0, '0']
- [isdbt_symbol_demapper_0, '0', isdbt_bit_deinterleaver_0_0, '0']
- [isdbt_symbol_demapper_0, '1', isdbt_bit_deinterleaver_0, '0']
- [isdbt_time_deinterleaver_0, '0', isdbt_symbol_demapper_0, '0']
- [isdbt_tmcc_decoder_0, '0', blocks_vector_to_stream_0_2, '0']
- [isdbt_tmcc_decoder_0, '0', isdbt_frequency_deinterleaver_0, '0']
- [isdbt_viterbi_decoder_0, '0', isdbt_byte_deinterleaver_0, '0']
- [isdbt_viterbi_decoder_0, '1', single_pole_iir_filter_xx_0_0, '0']
- [isdbt_viterbi_decoder_0_0, '0', isdbt_byte_deinterleaver_0_0, '0']
- [isdbt_viterbi_decoder_0_0, '1', single_pole_iir_filter_xx_0_0_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [single_pole_iir_filter_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
